# Keil uVision project Vl53l5cx_FirmwareLoader.uvprojx, settings and files
target Vl53l5cx_FirmwareLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Vl53l5cx_FirmwareLoader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F302xC
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\swl\swl_ExternalFlash;..\hwl\hwl_ExternalFlash;..\hwl\hwl_HardwareControl;..\swl\swl_HardwareControl;..\swl\swl_FlashLoader;..\swl\swl_Buffers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: Vl53l5cx_FirmwareLoader\Vl53l5cx_FirmwareLoader.sct
  group Application/MDK-ARM
    ./: startup_stm32f302xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group swl_ExternalFlash
    ../swl/swl_ExternalFlash/: swl_ExternalFlash.c swl_ExternalFlash.h
  group hwl_ExternalFlash
    ../hwl/hwl_ExternalFlash/: hwl_ExternalFlash.c hwl_ExternalFlash.h
  group swl_HardwareControl
    ../swl/swl_HardwareControl/: swl_HardwareControl.c swl_HardwareControl.h
  group hwl_HardwareControl
    ../hwl/hwl_HardwareControl/: hwl_HardwareControl.c hwl_HardwareControl.h
  group swl_FlashLoader
    ../swl/swl_FlashLoader/: swl_FlashLoader.c swl_FlashLoader.h
  group swl_Buffers
    ../swl/swl_Buffers/: swl_Buffers.h
software components: CMSIS:CORE 4.3.0
